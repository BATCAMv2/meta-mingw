CFLAGS_append_mingw32 = " -DLIBXML_STATIC"
EXTRA_OECONF_append_mingw32 = " --enable-static --disable-shared "
