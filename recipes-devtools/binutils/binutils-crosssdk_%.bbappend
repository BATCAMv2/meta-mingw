BINUPV_mingw32 = "2_27"
SRCREV_mingw32 = "5fe53ce37f9d9dd544ec8cc9e2863b68e1a61f4c"
SRC_URI_mingw32 = "\
    git://sourceware.org/git/binutils-gdb.git;branch=binutils-${BINUPV}-branch;protocol=git \
    "
